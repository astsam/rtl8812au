## Kconfig
```kconfig
config 88XXAU
	tristate "Realtek 88XXau USB WiFi"
	depends on USB
	---help---
	  Support for 8812au, 8821au and 8814au
```
